Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: 8dca99f9-ddae-4d82-bd13-67e4f511fcfb, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Default Site]
File name: Vitra-Office_Chairs-ACX_Pad_rfa.ifc
Time: 2025-11-24T00:54:32+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.70.22 (ENU) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1; sets with these values: 2
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: Vitra-Office_Chairs-ACX_Pad_rfa:ACX Pad, Vitra-Office_Chairs-ACX_Pad_rfa:ACX Pad:38145
In: Level 1
Type - Material: Black (textured), Deep black powder-coated
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Office_Chairs-ACX_Pad_rfa; Features: synchronised mechanism with automatic weight adjustment and two backrest resistance settings (hard or soft). Equipped as standard with seat height and seat depth adjustment. Optionally available with or without synchronised forward tilt (can be disengaged). Mechanism can be locked in upright sitting position. Seat mechanism matches the frame colour (deep black or soft grey).; Finish: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Pad_rfa; ReplacementCost: n/a; Shape: Sculptured; Size: 495x550x1060; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Constraints - Default Elevation: 0 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Office_Chairs-ACX_Pad_rfa; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Designed by Ronan and Erwan Bouroullec, the Softshell Chair mounted on a height-adjustable five-star swivel base with castors is ideal for studio offices. Its contours and quality materials give it an inviting appeal, while the soft upholstery guarantees superb comfort.; Revision: 0; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 13/11/2025
Type - Identity Data - Collection: ACX; Cost: 0; Description: Thanks to its automatic synchronised mechanism, the compact task chair ACX provides instant ergonomic comfort for users of different sizes – without them having to adjust anything except the seat height. The necessary functions and operating elements are carefully integrated in the chair's construction, whose clean lines convey an inviting understated aesthetic. The construction, materials, production, logistics and maintenance of ACX are designed to achieve a long life cycle with the smallest possible carbon footprint.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: ACX Pad; OmniClass Number: 23.40.20.14.14.11; Type Name: ACX Pad
Type - Materials and Finishes - Armrestcushion material: Black (textured)
Type - Pset_ElementShading - Color: Various
Type - Pset_FurnitureTypeChair - SeatingHeight: 355 mm; HighestSeatingHeight: 355 mm; LowestSeatingHeight: 355 mm
Type - Pset_FurnitureTypeCommon - Description: Thanks to its automatic synchronised mechanism, the compact task chair ACX provides instant ergonomic comfort for users of different sizes – without them having to adjust anything except the seat height. The necessary functions and operating elements are carefully integrated in the chair's construction, whose clean lines convey an inviting understated aesthetic. The construction, materials, production, logistics and maintenance of ACX are designed to achieve a long life cycle with the smallest possible carbon footprint.; Style: n/a; NominalHeight: 1060.56 mm; NominalLength: 495 mm; NominalDepth: 550 mm; MainColor: Various
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Type - Pset_ProductRequirements - Name: Pad_rfa
Material: Deep black powder-coated, Black (textured), Marron/Cognac, Coffee
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_QuantityTakeOff - Reference: ACX Pad
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Office_Chairs-ACX_Pad_rfa; Family and Type: Vitra-Office_Chairs-ACX_Pad_rfa: ACX Pad; InstallationDate: n/a; Material: Metal, Textile and Plastic; SerialNumber: n/a; TagNumber: n/a; Type: ACX Pad; Type Id: 38129; WarrantyStartDate: n/a
Constraints - Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Construction - ArmrestType: yes; ArmrestVisibility: yes
Dimensions - Area: 1.98851 m2; Volume: 0.525419 m3
Materials and Finishes - Backrest colour: Marron/Cognac; Base On: Black (textured); Frame colour: Deep black powder-coated; Seat colour: Coffee
Phasing - Phase Created: New Construction
